Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2011-11-26T19:51:14
Written by: Autodesk Revit Architecture 2011 - 1.0
Made in: 20100326_1700(x64)

# IfcSite, Par défaut
RefLatitude: 48, 52, 53, 759999; RefLongitude: 2, 25, 58, 79999; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
PSet_Revit_Autre - Adresse du projet: Entrer l'adresse ici

# IfcBuildingStorey, Niveau 0
Elevation: -0.188103 m
PSet_Revit_Données d'identification - Nom: Niveau 0
PSet_Revit_Contraintes - Elévation: -0.188103 m
PSet_Revit_Type_Graphismes - Epaisseur des lignes: 1; Couleur: 12632256; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
PSet_Revit_Type_Contraintes - Base de l'élévation: 0
PSet_Revit_Type_Cotes - Hauteur de calcul de pièce automatique: yes

# IfcBuildingElementProxy: CUR010054-3D-T-FBLR, CUR010054-3D-T-FBLR:CUR010054-3D-T-FBLR:CUR010054-3D-T-FBLR:187549
In: Niveau 0
PSet_Revit_Contraintes - Niveau: Niveau 0; Hôte: Niveau : Niveau 0; Décalage: 0 m; Se déplace avec les éléments voisins: no
PSet_Revit_Phase de construction - Phase Création: Nouvelle construction
